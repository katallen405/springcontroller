Commit message: created 2DoF visualization, debugged issues, fixed jacobian to match pinocchio

File: simple_2dof_arm.urdf (robot description, URDF)
Before this commit: robot simple_2dof_arm, 5 links, 4 joints
Joints:
- joint joint_1: axis 0 1 0 -> 0 -1 0
- joint joint_2: axis 0 1 0 -> 0 -1 0
